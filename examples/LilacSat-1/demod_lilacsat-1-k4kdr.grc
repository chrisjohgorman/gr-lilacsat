options:
  parameters:
    author: WEI Mingchuan, BG2BHC
    category: Custom
    description: LilacSat-1 9600 bps BPSK telemetry demodulator. Tested on GRC 3.7.8.
    generate_options: qt_gui
    id: demod_lilacsat1
    output_language: python
    title: Demod LilacSat-1
  states: {}

blocks:
- name: af_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@2:0,0
    label: AF Gain
    type: real
    value: '0'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: digigain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0
    type: real
    value: '20'
  states: {}
- name: equalizer_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1:3,0
    label: 'Equalizer: Gain'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: '0.05'
  states: {}
- name: fll_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1:0,0
    label: 'FLL: Bandwidth'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.001'
    stop: '0.2'
    value: '0.01'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1:2,0
    label: 'Phase: Bandwidth'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '0.02'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), alpha, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1:1,0
    label: 'Time: Bandwidth'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: '0.05'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    dims: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '1024'
    reference: '2'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '8000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/k4kdr/gr-lilacsat/examples/LilacSat-1/kml/2017-06-23--1405.kml
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(digigain/20)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10.0**(af_gain/20.0)
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    comment: |-
      Disable if not
       using Proxy
    host: 127.0.0.1
    mtu: '10000'
    port: '60061'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    comment: |-
      Disable if not running
       Image Decoder
      -----
      ORIG TCPnoDelay= Disabled
      -----
      ORIG MTU = 10000
    host: 127.0.0.1
    mtu: '10000'
    port: '60069'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '7200'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: phase_bw
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '100'
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: fll_bw
  states: {}
- name: digital_lms_dd_equalizer_cc_0_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: variable_constellation_0
    mu: equalizer_gain
    num_taps: '2'
    sps: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '0.05'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from grc_param import *
  states: {}
- name: lilacsat_codec2_decode_bf_0
  id: lilacsat_codec2_decode_bf
  parameters:
    mode: '0'
  states: {}
- name: lilacsat_kiss_encode_pdu_0
  id: lilacsat_kiss_encode_pdu
  parameters:
    comment: Disable if not using Proxy
    const_length: '-1'
  states: {state: disabled}
- name: lilacsat_lilacsat1_frame_depack_0
  id: lilacsat_lilacsat1_frame_depack
  parameters:
    maxoutbuf: '4'
  states: {}
- name: lilacsat_plan13_cc_0
  id: lilacsat_plan13_cc
  parameters:
    comment: |-
      Orig Center Freq: 436510000
      ** Enable = "Off" to defeat doppler on replay
    enable: 'False'
    fc: '436510000'
    height: alt
    lat: lat
    lon: lon
    samp_rate: samp_rate
    tle1: tle_line1
    tle2: tle_line2
    txrx: 'False'
    verbose: 'False'
  states: {}
- name: lilacsat_sync_det_b_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '116'
    nrz: 'True'
    sync_word: '0x1ACFFC1D'
  states: {}
- name: lilacsat_sync_det_b_0_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '116'
    nrz: 'True'
    sync_word: '0x1ACFFC1D'
  states: {}
- name: lilacsat_vitfilt27_fb_0
  id: lilacsat_vitfilt27_fb
  parameters: {}
  states: {}
- name: lilacsat_vitfilt27_fb_0_0
  id: lilacsat_vitfilt27_fb
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Orig cutoff: 10e3
      Cutoff = 15e3 first QSO w/ Bob
      Cutoff = 20e3 w/ 1k trans width working best
      Orig trans width: 2e3
    cutoff_freq: 20e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,1,2
    label1: A
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 48e3
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    label2: ''
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '0.001'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 0,1
    label1: RSSI
    name: ''
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@2:1,0
    label1: ''
    size: '1000'
    srate: '8000'
    type: float
    update_time: '0.125'
  states: {}
- name: satellites_by701_image_decoder_0
  id: satellites_by701_image_decoder
  parameters:
    display: 'True'
    path: /home/k4kdr/gr-lilacsat/examples/LilacSat-1/images
  states: {}
- name: satellites_by701_telemetry_parser_0
  id: satellites_by701_telemetry_parser
  parameters: {}
  states: {}
- name: satellites_lilacsat1_gps_kml_0
  id: satellites_lilacsat1_gps_kml
  parameters: {}
  states: {state: disabled}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_swap_header_0
  id: satellites_swap_header
  parameters: {}
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,2
    label0: Spectrum
    label1: Loop
    label2: Audio
    num_tabs: '3'
  states: {}

connections:
- [analog_feedforward_agc_cc_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_complex_to_real_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_real_0, '0', lilacsat_vitfilt27_fb_0, '0']
- [blocks_delay_0, '0', lilacsat_vitfilt27_fb_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', lilacsat_plan13_cc_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_rms_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_udp_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', lilacsat_sync_det_b_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_1, '0', lilacsat_sync_det_b_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_lms_dd_equalizer_cc_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [digital_lms_dd_equalizer_cc_0_0, '0', blocks_complex_to_real_0, '0']
- [digital_lms_dd_equalizer_cc_0_0, '0', qtgui_const_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0_0, '0']
- [lilacsat_codec2_decode_bf_0, '0', blocks_multiply_const_vxx_1, '0']
- [lilacsat_codec2_decode_bf_0, '0', qtgui_time_sink_x_0, '0']
- [lilacsat_kiss_encode_pdu_0, out, blocks_socket_pdu_0, pdus]
- [lilacsat_kiss_encode_pdu_0, out, blocks_socket_pdu_0_0, pdus]
- [lilacsat_lilacsat1_frame_depack_0, '0', lilacsat_codec2_decode_bf_0, '0']
- [lilacsat_lilacsat1_frame_depack_0, out, blocks_message_debug_0, print_pdu]
- [lilacsat_lilacsat1_frame_depack_0, out, lilacsat_kiss_encode_pdu_0, in]
- [lilacsat_lilacsat1_frame_depack_0, out, satellites_print_timestamp_0, in]
- [lilacsat_plan13_cc_0, '0', low_pass_filter_0, '0']
- [lilacsat_sync_det_b_0, out, lilacsat_lilacsat1_frame_depack_0, in]
- [lilacsat_sync_det_b_0_0, out, lilacsat_lilacsat1_frame_depack_0, in]
- [lilacsat_vitfilt27_fb_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [lilacsat_vitfilt27_fb_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_1, '0']
- [low_pass_filter_0, '0', analog_feedforward_agc_cc_0, '0']
- [low_pass_filter_0, '0', blocks_rms_xx_0, '0']
- [satellites_lilacsat1_gps_kml_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_print_timestamp_0, out, satellites_swap_header_0, in]
- [satellites_swap_header_0, out, satellites_by701_image_decoder_0, in]
- [satellites_swap_header_0, out, satellites_by701_telemetry_parser_0, in]
- [satellites_swap_header_0, out, satellites_lilacsat1_gps_kml_0, in]

metadata:
  file_format: 1
