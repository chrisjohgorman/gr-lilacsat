options:
  parameters:
    author: YU Yang; WEI Mingchuan, BG2BHC
    category: Custom
    description: LilacSat-2 4800 bps GFSK telemetry demodulator. Tested on GRC 3.7.8.
    generate_options: qt_gui
    id: demod_node4_4k8
    output_language: python
    title: 'Demod Node4: 4k8'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/lilac/dslwp_ssdv_test_2k_20170630.raw
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 2e6
    type: complex
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '8'
    sensitivity: '2.0'
  states: {}
- name: lilacsat_dslwp_tm_header_parser_0
  id: lilacsat_dslwp_tm_header_parser
  parameters: {}
  states: {}
- name: lilacsat_fec_decode_b_0
  id: lilacsat_fec_decode_b
  parameters:
    frame_len: '223'
    pass_all: 'True'
    using_convolutional_code: 'True'
    using_m: 'False'
  states: {}
- name: lilacsat_fec_decode_b_0_0
  id: lilacsat_fec_decode_b
  parameters:
    frame_len: '223'
    pass_all: 'True'
    using_convolutional_code: 'True'
    using_m: 'False'
  states: {}
- name: lilacsat_file_sink_pdu_0
  id: lilacsat_file_sink_pdu
  parameters:
    format: '0'
    path: /home/lilac/data_ssdv.bin
  states: {state: disabled}
- name: lilacsat_kiss_decode_pdu_0
  id: lilacsat_kiss_decode_pdu
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/24
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0
    label1: ''
    size: '128'
    srate: '4800'
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', lilacsat_fec_decode_b_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', digital_gfsk_demod_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gfsk_demod_0, '0', blocks_char_to_float_0, '0']
- [digital_gfsk_demod_0, '0', blocks_delay_0, '0']
- [digital_gfsk_demod_0, '0', lilacsat_fec_decode_b_0, '0']
- [lilacsat_dslwp_tm_header_parser_0, out 1, lilacsat_kiss_decode_pdu_0, in]
- [lilacsat_fec_decode_b_0, out, lilacsat_dslwp_tm_header_parser_0, in]
- [lilacsat_fec_decode_b_0_0, out, lilacsat_dslwp_tm_header_parser_0, in]
- [lilacsat_kiss_decode_pdu_0, out, blocks_message_debug_0, print_pdu]
- [lilacsat_kiss_decode_pdu_0, out, lilacsat_file_sink_pdu_0, in]

metadata:
  file_format: 1
