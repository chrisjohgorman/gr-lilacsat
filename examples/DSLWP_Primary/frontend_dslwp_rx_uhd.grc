options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: frontend_trx_node1_uhd
    output_language: python
    title: Frontend TRX NODE1 UHD
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 436.075e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '73'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    label: TX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '89'
    value: '33.5'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 74.26e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 50e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7200'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7201'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7226'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_1
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7225'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '4096'
    gui_hint: tab@1
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '5'
    fc: fc
    fftsize: '1024'
    gui_hint: tab@0
    int_max: '0'
    int_min: '-100'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '24'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '24'
    taps: ''
    type: ccc
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0
    label0: Waterfall
    label1: Spectrum
    num_tabs: '2'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: fc
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_gain
    hide_cmd_port: 'False'
    hide_lo_controls: 'True'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: ''
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_udp_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_udp_sink_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_udp_sink_0_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_udp_sink_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
