options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: BY70-1 telemetry replay using opensource image decoder
    generate_options: qt_gui
    id: replay_by70_1_opensource_decoder
    output_language: python
    title: Replay BY70-1
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: digigain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0
    type: real
    value: '20'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), alpha, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    dims: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/Descargas/record_by70-1_image.bin
    repeat: 'False'
    type: float
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '9600'
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: csp_print_header_0
  id: csp_print_header
  parameters: {}
  states: {state: disabled}
- name: csp_swap_header_0
  id: csp_swap_header
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: lilacsat_fec_decode_b_0_0
  id: lilacsat_fec_decode_b
  parameters:
    frame_len: '114'
    pass_all: 'False'
    using_convolutional_code: 'False'
    using_m: 'True'
  states: {}
- name: lilacsat_fec_decode_b_0_0_0
  id: lilacsat_fec_decode_b
  parameters:
    frame_len: '114'
    pass_all: 'False'
    using_convolutional_code: 'False'
    using_m: 'True'
  states: {}
- name: lilacsat_image_decoder_0
  id: lilacsat_image_decoder
  parameters:
    display: 'True'
    path: /tmp
  states: {}
- name: lilacsat_kiss_decode_pdu_0
  id: lilacsat_kiss_decode_pdu
  parameters: {}
  states: {}
- name: lilacsat_telemetry_parser_0
  id: lilacsat_telemetry_parser
  parameters: {}
  states: {}
- name: lilacsat_vitfilt27_fb_0
  id: lilacsat_vitfilt27_fb
  parameters: {}
  states: {}
- name: lilacsat_vitfilt27_fb_0_0
  id: lilacsat_vitfilt27_fb
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_delay_0, '0', lilacsat_vitfilt27_fb_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_delay_0, '0']
- [blocks_throttle_0, '0', lilacsat_vitfilt27_fb_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', lilacsat_fec_decode_b_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0, '0', lilacsat_fec_decode_b_0_0, '0']
- [csp_swap_header_0, out, blocks_message_debug_1, print_pdu]
- [csp_swap_header_0, out, csp_print_header_0, in]
- [csp_swap_header_0, out, lilacsat_image_decoder_0, in]
- [csp_swap_header_0, out, lilacsat_telemetry_parser_0, in]
- [lilacsat_fec_decode_b_0_0, out, lilacsat_kiss_decode_pdu_0, in]
- [lilacsat_fec_decode_b_0_0_0, out, lilacsat_kiss_decode_pdu_0, in]
- [lilacsat_kiss_decode_pdu_0, out, csp_swap_header_0, in]
- [lilacsat_vitfilt27_fb_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [lilacsat_vitfilt27_fb_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_0, '0']

metadata:
  file_format: 1
