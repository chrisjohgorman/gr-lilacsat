options:
  parameters:
    author: WEI Mingchuan, BG2BHC
    category: Custom
    description: LilacSat-2 receiver frontend for FCDPP. Tested on GRC 3.7.8.
    generate_options: qt_gui
    id: frontend_rx_fcdpp
    output_language: python
    title: Frontend RX FCDPP
  states: {}

blocks:
- name: if_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,2
    label: IF Gain
    type: int
    value: '10'
  states: {}
- name: lna
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,0
    label: LNA
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: mixergain
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,1
    label: Mixergain
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 60e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 35e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/lilac/record
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7200'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7201'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7226'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_1
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7225'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: fcdproplus_fcdproplus_0
  id: fcdproplus_fcdproplus
  parameters:
    device_name: ''
    freq: '437260000'
    if_gain: if_gain
    lnaswitch: lna
    mixergainswitch: mixergain
    ppm: '0'
    unit: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 437.26e6
    fftsize: '1024'
    gui_hint: tab@1
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: tab@2
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '5'
    fc: 437.26e6
    fftsize: '1024'
    gui_hint: tab@0
    int_max: '0'
    int_min: '-100'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,3
    label0: Waterfall
    label1: Spectrum
    label2: Scope
    num_tabs: '3'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [fcdproplus_fcdproplus_0, '0', blocks_file_sink_0, '0']
- [fcdproplus_fcdproplus_0, '0', blocks_multiply_xx_0, '0']
- [fcdproplus_fcdproplus_0, '0', blocks_multiply_xx_0_0, '0']
- [fcdproplus_fcdproplus_0, '0', qtgui_freq_sink_x_0, '0']
- [fcdproplus_fcdproplus_0, '0', qtgui_time_sink_x_0, '0']
- [fcdproplus_fcdproplus_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_udp_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_udp_sink_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_udp_sink_0_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_udp_sink_0_1, '0']

metadata:
  file_format: 1
