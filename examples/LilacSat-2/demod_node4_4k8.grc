options:
  parameters:
    author: YU Yang; WEI Mingchuan, BG2BHC
    category: Custom
    description: LilacSat-2 4800 bps GFSK telemetry demodulator. Tested on GRC 3.7.8.
    generate_options: qt_gui
    id: demod_node4_4k8
    output_language: python
    title: 'Demod Node4: 4k8'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: byte
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '60062'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '7225'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '10'
    sensitivity: '2.0'
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from grc_param import *
  states: {}
- name: lilacsat_fec_decode_b_0
  id: lilacsat_fec_decode_b
  parameters:
    frame_len: '114'
    pass_all: 'False'
    using_convolutional_code: 'True'
    using_m: 'False'
  states: {}
- name: lilacsat_fec_decode_b_0_0
  id: lilacsat_fec_decode_b
  parameters:
    frame_len: '114'
    pass_all: 'False'
    using_convolutional_code: 'True'
    using_m: 'False'
  states: {}
- name: lilacsat_kiss_decode_pdu_0
  id: lilacsat_kiss_decode_pdu
  parameters: {}
  states: {}
- name: lilacsat_plan13_cc_0
  id: lilacsat_plan13_cc
  parameters:
    enable: 'True'
    fc: '437225000'
    height: alt
    lat: lat
    lon: lon
    samp_rate: samp_rate
    tle1: tle_line1
    tle2: tle_line2
    txrx: 'False'
    verbose: 'True'
  states: {}
- name: low_pass_filter_3_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: 48e3
    type: fir_filter_ccf
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: 0,0
    label2: ''
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0
    label1: ''
    size: '128'
    srate: '4800'
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', lilacsat_fec_decode_b_0_0, '0']
- [blocks_udp_source_0, '0', lilacsat_plan13_cc_0, '0']
- [blocks_udp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gfsk_demod_0, '0', blocks_char_to_float_0, '0']
- [digital_gfsk_demod_0, '0', blocks_delay_0, '0']
- [digital_gfsk_demod_0, '0', lilacsat_fec_decode_b_0, '0']
- [lilacsat_fec_decode_b_0, out, lilacsat_kiss_decode_pdu_0, in]
- [lilacsat_fec_decode_b_0_0, out, lilacsat_kiss_decode_pdu_0, in]
- [lilacsat_kiss_decode_pdu_0, out, blocks_message_debug_1, print_pdu]
- [lilacsat_kiss_decode_pdu_0, out, blocks_socket_pdu_0, pdus]
- [lilacsat_plan13_cc_0, '0', low_pass_filter_3_0_0, '0']
- [lilacsat_plan13_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [low_pass_filter_3_0_0, '0', digital_gfsk_demod_0, '0']

metadata:
  file_format: 1
