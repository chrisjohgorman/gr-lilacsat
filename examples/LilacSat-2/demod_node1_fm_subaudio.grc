options:
  parameters:
    author: WEI Mingchuan, BG2BHC
    category: Custom
    description: LilacSat-2 300 bps FM subaudio telemetry demodulator. Tested on GRC 3.7.8.
    generate_options: qt_gui
    id: demod_node1_fm_subaudio
    output_language: python
    title: 'Demod Node1: FM Subaudio'
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), alpha, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '9600'
    max_dev: 3.5e3
    quad_rate: '48000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '9600'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '60061'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '7201'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.0628'
    max_dev: '0.01'
    osps: '1'
    sps: '32'
    taps: rrc_taps
    type: fff
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from grc_param import *
  states: {}
- name: lilacsat_fec_decode_b_0_0_2
  id: lilacsat_fec_decode_b
  parameters:
    frame_len: '114'
    pass_all: 'False'
    using_convolutional_code: 'False'
    using_m: 'False'
  states: {}
- name: lilacsat_kiss_decode_pdu_0
  id: lilacsat_kiss_decode_pdu
  parameters: {}
  states: {}
- name: lilacsat_plan13_cc_0
  id: lilacsat_plan13_cc
  parameters:
    enable: 'True'
    fc: '437200000'
    height: alt
    lat: lat
    lon: lon
    samp_rate: samp_rate
    tle1: tle_line1
    tle2: tle_line2
    txrx: 'False'
    verbose: 'True'
  states: {}
- name: low_pass_filter_3_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    decim: '1'
    gain: '1'
    samp_rate: 48e3
    type: fir_filter_ccf
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: 0,0
    label2: ''
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: '9600'
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0
    name: ''
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1
    label1: ''
    name: ''
    size: '32'
    srate: '9600'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,1
    label1: ''
    label2: ''
    name: ''
    nconnections: '2'
    size: 32*32
    srate: '9600'
    type: float
  states: {}

connections:
- [analog_nbfm_rx_0, '0', dc_blocker_xx_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_float_to_char_0, '0', lilacsat_fec_decode_b_0_0_2, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_udp_source_0, '0', lilacsat_plan13_cc_0, '0']
- [blocks_udp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [dc_blocker_xx_0, '0', audio_sink_0, '0']
- [dc_blocker_xx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [dc_blocker_xx_0, '0', qtgui_freq_sink_x_2, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_0_0, '1']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_threshold_ff_0, '0']
- [lilacsat_fec_decode_b_0_0_2, out, lilacsat_kiss_decode_pdu_0, in]
- [lilacsat_kiss_decode_pdu_0, out, blocks_message_debug_1, print_pdu]
- [lilacsat_kiss_decode_pdu_0, out, blocks_socket_pdu_0, pdus]
- [lilacsat_plan13_cc_0, '0', low_pass_filter_3_0_0, '0']
- [lilacsat_plan13_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [low_pass_filter_3_0_0, '0', analog_nbfm_rx_0, '0']

metadata:
  file_format: 1
